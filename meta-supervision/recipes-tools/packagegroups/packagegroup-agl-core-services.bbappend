RDEPENDS_${PN}_agl-devel += "\
   promtail \
"
