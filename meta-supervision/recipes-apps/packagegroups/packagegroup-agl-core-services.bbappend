RDEPENDS_${PN}_agl-devel += "\
   agl-service-xds-monitoring \
   agl-service-harvester \
"
