TOOLCHAIN_TARGET_TASK += "julius-staticdev"
