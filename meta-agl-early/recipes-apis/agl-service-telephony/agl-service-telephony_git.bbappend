FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
file://0001-telephony-binding-handle-vshl-interface.patch \
file://0002-draft-patch-able-to-make-a-call-with-alexa.patch \
"
