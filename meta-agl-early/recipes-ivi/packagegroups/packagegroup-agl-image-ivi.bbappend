RDEPENDS_${PN} += " \
	packagegroup-ivi-identity \
	agl-service-signal-composer \
"
