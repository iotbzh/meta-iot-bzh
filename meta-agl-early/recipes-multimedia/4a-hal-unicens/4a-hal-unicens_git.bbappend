SRC_URI = "gitsm://github.com/tjahnk/4a-hal-unicens;protocol=https;nobranch=1"
SRCREV = "8be9b941f6364ba8f251ef6acb95350a8e289ce3"

