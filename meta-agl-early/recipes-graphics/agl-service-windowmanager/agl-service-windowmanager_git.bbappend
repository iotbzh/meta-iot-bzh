AGL_BRANCH = "sandbox/ruke47/lifecycle"
SRCREV="${AUTOREV}"
