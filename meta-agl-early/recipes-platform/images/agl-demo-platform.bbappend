RDEPENDS += "packagegroup-demo-hmi"

