RDEPENDS_${PN} += " \
	agl-identity-agent \
	agl-service-signal-composer \
	"
