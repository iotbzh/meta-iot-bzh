RDEPENDS_${PN} += "\
agl-service-amazon-widgets \
agl-service-voice-high \
agl-service-voice-high-support \
    "
