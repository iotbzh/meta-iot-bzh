RDEPENDS_${PN} += "\
   platform-test \
"
