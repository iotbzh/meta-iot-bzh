DEPENDS += "coreutils-native"
