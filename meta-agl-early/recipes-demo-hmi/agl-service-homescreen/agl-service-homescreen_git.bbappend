FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
file://0001-hs-client-showWindow-display-an-app.patch \
"
SRCREV = "${AUTOREV}"

