SRC_URI = "git://gerrit.automotivelinux.org/gerrit/apps/hvac;protocol=https;branch=sandbox/claneys/multilang"
SRCREV  = "${AUTOREV}"

DEPENDS += " qttools-native"
