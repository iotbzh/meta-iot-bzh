ALLOW_EMPTY_${PN} = "1"

RDEPENDS_${PN} += "\
    agl-identity-agent \
"

LICENSE = "MIT"

