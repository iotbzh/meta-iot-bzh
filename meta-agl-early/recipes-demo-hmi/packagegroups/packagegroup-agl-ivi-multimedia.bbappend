RDEPENDS_${PN} += "\
    agl-spotify-binding \
"

