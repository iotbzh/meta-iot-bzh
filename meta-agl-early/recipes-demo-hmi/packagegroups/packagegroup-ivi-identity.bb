ALLOW_EMPTY_${PN} = "1"

RDEPENDS_${PN} += "\
    agl-service-data-persistence \
    agl-identity-agent \
    agl-spotify-binding \
"

LICENSE = "MIT"

