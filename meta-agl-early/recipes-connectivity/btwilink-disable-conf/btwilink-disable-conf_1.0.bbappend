COMPATIBLE_MACHINE = "(m3ulcb|h3ulcb)"
