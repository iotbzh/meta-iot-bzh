FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
file://0001-generate-unit-conf-binder.inc-htdocs-for-CES-demo.patch \
"
