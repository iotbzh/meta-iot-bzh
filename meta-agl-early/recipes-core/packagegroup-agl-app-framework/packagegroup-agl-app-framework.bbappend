RDEPENDS_${PN} += "\
   af-binder-alt \
"

