FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI = "\
	file://web-runtime;md5sum=2245be1e6029b30966f0842e3fee75ea \
	file://web-runtime.qml;md5sum=922aeae6d596d7c83af01abca266f0df \
	file://web-runtime-webkit.qml;md5sum=4daf9df39078634c27a7923d37e82e3d \
"

