# only for rcar platforms
RDEPENDS_${PN}_append_ulcb = "rcar-pvr-watchdog"

