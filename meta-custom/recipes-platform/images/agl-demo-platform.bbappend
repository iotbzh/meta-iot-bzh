require agl-demo-setrootpasswd.inc

