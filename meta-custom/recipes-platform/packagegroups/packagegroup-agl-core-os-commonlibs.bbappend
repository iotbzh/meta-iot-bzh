RDEPENDS_${PN} += "\
	platform-hardware-info \
"

