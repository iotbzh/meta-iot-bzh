RDEPENDS_${PN} += "\
	iotbzh-base-files \
	xdelta3 \
	v4l-utils \
	ffmpeg \
	i2c-tools \
"

