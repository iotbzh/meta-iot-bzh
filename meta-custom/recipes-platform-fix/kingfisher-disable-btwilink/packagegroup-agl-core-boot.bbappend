RDEPENDS_${PN} += "\
    kingfisher-disable-btwilink \
"

