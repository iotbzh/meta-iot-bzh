RDEPENDS_${PN} += "\
	fix-startup-sequence \
"

