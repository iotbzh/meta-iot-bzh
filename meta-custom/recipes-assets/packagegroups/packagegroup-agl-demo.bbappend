RDEPENDS_${PN} += "\
    agl-demo-assets \
"
