RDEPENDS_${PN} += "\
	lxc \
"

