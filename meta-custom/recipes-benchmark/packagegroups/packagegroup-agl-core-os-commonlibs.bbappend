RDEPENDS_${PN} += "\
    packagegroup-benchmark \
"

