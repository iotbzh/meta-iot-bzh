TOOLCHAIN_TARGET_TASK += " \
    libafb-helpers-staticdev \
    libappcontroller-staticdev \
"
