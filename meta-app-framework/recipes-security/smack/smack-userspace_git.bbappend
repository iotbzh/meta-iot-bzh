PV = "1.1.0+git${SRCPV}"
SRCREV = "f9515f4a36e1cbdf852f14fb46e6b92914383a1b"
SRC_URI = "git://github.com/smack-team/smack.git;protocol=https;branch=v1.1.x"

