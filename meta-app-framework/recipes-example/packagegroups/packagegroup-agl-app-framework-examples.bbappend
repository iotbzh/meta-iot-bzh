RDEPENDS_${PN} += "\
	afm-widget-examples \
    "
