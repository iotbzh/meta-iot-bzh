RDEPENDS_${PN} += "\
	afm-widget-examples \
	afm-client \
    "
