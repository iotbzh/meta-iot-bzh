RDEPENDS_${PN} += "\
	afm-main \
	afb-daemon \
	afb-client \
	afb-radio \
	web-runtime \
    "
