FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI += "file://removing-capability-enforcement.patch"
