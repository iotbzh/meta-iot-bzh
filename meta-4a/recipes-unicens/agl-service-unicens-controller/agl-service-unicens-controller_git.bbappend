SRC_URI = "gitsm://gerrit.automotivelinux.org/gerrit/apps/agl-service-unicens-controller;protocol=https;branch=master"
SRCREV = "e91eaa18befd14446d280311c9bd5c05f29801f0"

