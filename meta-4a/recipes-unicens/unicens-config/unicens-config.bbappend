# override unicens-config.sh (initially located on master branch in meta-agl-demo:b01dec9, gerrit change #22918/2)

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


