SRC_URI = "gitsm://gerrit.automotivelinux.org/gerrit/apps/agl-service-unicens;protocol=https;branch=master"
SRCREV = "495e78645e74ab7ef0323fb1b403e3a881a73db7"


