SUMMARY     = "Mediaplayer Service Binding"
DESCRIPTION = "AGL Mediaplayer Service Binding (4A version)"
HOMEPAGE    = "http://git.ovh.iot/4a/"

SRC_URI = "gitsm://git.ovh.iot/4a/agl-service-mediaplayer.git;protocol=http;branch=${4A_BRANCH}"
SRCREV  = "${AUTOREV}"

