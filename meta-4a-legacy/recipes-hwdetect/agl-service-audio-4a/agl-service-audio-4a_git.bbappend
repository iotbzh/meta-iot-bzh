FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
file://0001-config-add-4a-hal-rcar-m3kf-unicens-as-api.patch \
"
