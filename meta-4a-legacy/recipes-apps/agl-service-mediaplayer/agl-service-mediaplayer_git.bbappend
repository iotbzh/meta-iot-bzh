SUMMARY     = "Mediaplayer Service Binding"
DESCRIPTION = "AGL Mediaplayer Service Binding (4A version)"
HOMEPAGE    = "http://git.ovh.iot/4a-legacy/"

SRC_URI = "gitsm://git.ovh.iot/4a-legacy/agl-service-mediaplayer.git;protocol=http;branch=4a-legacy"
SRCREV  = "19967d445de87effaf897c2cf51335583f7c86c9"

