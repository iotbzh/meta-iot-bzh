TOOLCHAIN_TARGET_TASK += "libavirt-staticdev"
