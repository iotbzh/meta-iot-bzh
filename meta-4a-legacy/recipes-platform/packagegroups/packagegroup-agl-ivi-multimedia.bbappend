
RDEPENDS_${PN}_remove = "packagegroup-pipewire"

RDEPENDS_${PN} += "\
	packagegroup-4a \
	"
