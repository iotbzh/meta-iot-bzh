RDEPENDS_${PN} += "\
	mpd \
	libmpdclient \
    "

