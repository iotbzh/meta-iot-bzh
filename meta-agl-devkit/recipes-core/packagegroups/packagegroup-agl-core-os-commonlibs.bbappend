RDEPENDS_${PN} += "\
	packagegroup-agl-devkit \
    "

