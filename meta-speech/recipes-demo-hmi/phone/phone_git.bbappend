FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
file://0001-CES2019-DIRTY-HACK-Dialer-react-service-events.patch \
"
