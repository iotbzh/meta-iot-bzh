FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "\
	file://0001-VoiceAgentEventsHandler-handle-mic-states.patch \
"

