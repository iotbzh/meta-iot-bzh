RDEPENDS_${PN} += "\
   agl-service-amazon-widgets \
"
