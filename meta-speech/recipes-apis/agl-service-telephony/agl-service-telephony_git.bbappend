FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
file://0001-telephony-binding-handle-vshl-interface.patch \
"
